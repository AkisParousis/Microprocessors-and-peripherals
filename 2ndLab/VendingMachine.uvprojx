# Keil uVision project VendingMachine.uvprojx, settings and files
target VendingMachine (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: VendingMachine
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1
  c misc: --diag_suppress 1300 --no_rtti --no_exceptions
  c include: ..;..\..;..\..\..;..\..\..\..\src;..\..\..\..\src\Application;..\..\..\..\..\..\redBlocks\src;..\..\..\..\..\..\redBlocks\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: main.cpp
    ../../../../src/Application/: AlarmManager.cpp Application.cpp CashBox.cpp GlobalState.cpp MaintenanceMode.cpp ProductSlot.cpp VendingMode.cpp
    ../../../../src/Gui/: MaintenanceScreen.cpp VendingScreen.cpp
    ../../../../src/Gui/GuiData/: Arial20.cpp Images.cpp
    ./: redBlocksEnv.cpp
    ../../../../src/: redBlocksLib.cpp
  group Libs
    ../../../../../../redBlocks/: libredBlocks_uvision.lib
software components: CMSIS:CORE 5.4.0, Device:Startup 1.2.2, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
